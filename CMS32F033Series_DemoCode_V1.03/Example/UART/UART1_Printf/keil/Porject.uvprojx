# Keil uVision project Porject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMS32F033 Cmsemicon
  pack: Cmsemicon.CMS32-Series.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Porject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Libary\CMSIS\Include;..\..\..\..\Libary\Device\CMS32F033\Include;..\..\..\..\Libary\StdDriver\inc;..\Lan_code;..\code
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../Libary/Device/CMS32F033/Source/ARM/: startup_cms_m0.s
    ../../../../Libary/Device/CMS32F033/Source/: system_cms_m0.c
  group LIB
    ../../../../Libary/StdDriver/src/: system.c uart.c retarget.c timer.c
  group User
    ../code/: main.c isr.c demo_uart.c demo_timer.c
    ../Lan_code/: SMG.c AD_Key.c CXN4016.c TX1812_5050.c Game_Operation.c
